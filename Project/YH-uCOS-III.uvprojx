# Keil uVision project YH-uCOS-III.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: YH-uCOS-III
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\User\uC-CPU;..\User\uC-LIB;..\User\uCOS-III\Ports;..\User\uCOS-III\Source;..\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: app.c
  group uC/OS-III Source
    ../User/uCOS-III/Source/: os.h os_cfg.h os_task.c os_var.c os_core.c os_type.h os_time.c os_cfg_app.c os_prio.c
  group uC/OS-III Ports
    ../User/uCOS-III/Ports/: os_cpu_a.s os_cpu.h
  group uC/CPU
    ../User/uC-CPU/: cpu.h os_cpu_c.c cpu_a.asm cpu_core.h cpu_core.c cpu_cfg.h cpu_def.h
    ../User/uC-LIB/: lib_def.h
  group Doc
    ../Doc/: readm.txt
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
